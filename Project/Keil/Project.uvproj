# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=9
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group Hardware
    ../../Hardware/: adc.c timer.c task.c pwm.c key.c motor_handle.c uart.c led.c
  group User
    ../../User/: main.c
    ../../Libraries/Source/: debug.c
